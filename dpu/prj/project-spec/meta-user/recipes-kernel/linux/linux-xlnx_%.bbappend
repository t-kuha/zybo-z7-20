SRC_URI += "file://user_2019-08-19-10-44-00.cfg \
            file://user_2019-08-21-05-22-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

