SRC_URI += "file://user_2018-12-26-02-24-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

