SRC_URI += "file://user_2019-02-12-18-47-00.cfg \
            file://user_2019-02-12-18-51-00.cfg \
            file://user_2019-02-12-18-58-00.cfg \
            file://user_2019-02-15-15-49-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

