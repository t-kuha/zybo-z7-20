FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://platform-top.h \
            file://user_2019-02-01-11-32-00.cfg \
            "
