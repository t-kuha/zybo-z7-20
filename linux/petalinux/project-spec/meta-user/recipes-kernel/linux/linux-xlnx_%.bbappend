SRC_URI += "file://user_2020-09-28-08-53-00.cfg \
            file://user_2020-09-28-09-07-00.cfg \
            file://user_2020-09-29-01-05-00.cfg \
            file://user_2020-09-29-01-30-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

